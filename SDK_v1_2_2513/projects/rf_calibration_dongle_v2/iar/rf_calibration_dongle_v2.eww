<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    <path>$WS_DIR$/rf_calibration_dongle_v2.ewp</path>
  </project>
  <batchBuild/>
</workspace>
