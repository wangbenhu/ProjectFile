# Keil uVision project example.uvprojx, settings and files
target example (6140000::V6.14::ARMCLANG)
  device: OM6627X Onmicro
  pack: Onmicro.OM6627X.1.0.0
  cpu: IROM(0x00400000,0x400000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(64000000) ELITTLE
  output: example
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "#L"
  AfterMake: fromelf.exe -c --output "$L@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: OM6627X=1,
  c include: ../config;../drv_example;../../../bsp/include;../../../common/include;../../../common/source;../../../components/om_log;../../../components/nvds;../../../components/pm;../../../hal/CMSIS/Core/Include;../../../hal/driver/include;../../../hal/device/include;
  asm define: OM6627X=1,
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: ../linker_script/KEIL/cm4f_flash.sct
  link misc: --diag_suppress=L6314 --diag_suppress=L6439W
../../../hal/device/ARM/libcpft.lib
  group main
    ../main/: main.c
  group drv_example
    ../drv_example/: example_aes.c example_audio.c example_efuse.c example_flash.c example_gpadc.c example_gpdma.c example_gpio.c example_i2c.c example_i2s.c example_ir.c example_lcd.c example_lptimer.c example_pmu_timer.c example_qdec.c example_rgb.c example_rtc.c example_spi.c example_timer.c example_uart.c example_wdt.c example_shelf_mode.c
  group bsp
    ../../../bsp/board_evb/: board_evb.c
    ../../../bsp/source/: glcd_gc9c01.c
  group common
    ../../../common/source/: om_printf.c om_mem.c om_ringbuff.c om_common.c om_fifo.c om_libc_retarget.c om_list.c
  group om_log
    ../../../components/om_log/: om_log.c om_log_port.c
  group nvds
    ../../../components/nvds/: nvds.c
  group pm
    ../../../components/pm/: pm.c
  group driver
    ../../../hal/driver/source/: drv_mpu.c drv_om24g.c drv_gpadc.c drv_aes.c drv_calib_repair.c drv_calib.c drv_gpdma.c drv_efuse.c drv_gpio.c drv_i2c.c drv_isr.c drv_lptim.c drv_pin.c drv_pmu_timer.c drv_pmu.c drv_radio.c drv_rcc.c drv_rng.c drv_rtc.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c drv_i2s.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_lcd.c drv_irtx.c drv_sha256.c drv_ospi.c drv_psram.c drv_qdec.c drv_rgb.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
    ../../../hal/driver/source/drv_flash/: drv_iflash.c drv_oflash.c drv_flash.c
  group startup
    ../../../hal/device/: system_cm4f.c
    ../../../hal/device/GCC/: startup_cm4f.S
