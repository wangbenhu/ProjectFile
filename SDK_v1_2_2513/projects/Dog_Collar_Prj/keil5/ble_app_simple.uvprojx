# Keil uVision project ble_app_simple.uvprojx, settings and files
target ble_app_simple (6180000::V6.18::ARMCLANG)
  device: OM6629X Onmicro
  pack: Onmicro.OM6629X.1.0.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00100000,0x00008000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Dog_Collar_V02010620260903
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "#L"
  AfterMake: fromelf.exe -c --output "$L@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CONFIG_BLE_HOST,CONFIG_LE_BROADCASTER=1,CONFIG_LE_PERIPHERAL=1,CONFIG_LE_ACTIVITY_NB=2,CONFIG_LE_CONNECTION_NB=1,CONFIG_LE_WHITELIST_NB=6,CONFIG_LE_LL_HCI_CMD_PKTS_NB=2,CONFIG_LE_LL_RX_DATA_BUF_NB=3,CONFIG_LE_LL_RX_DATA_BUF_SIZE=256,CONFIG_LE_LL_TX_ACL_BUF_NB=3,CONFIG_LE_LL_TX_ACL_BUF_SIZE=256,CONFIG_LE_LL_TX_ADV_BUF_NB=2,CONFIG_LE_LL_TX_ADV_FRAG_NB=1,CONFIG_LE_LL_TX_ADV_FRAG_BUF_SIZE=37,CONFIG_LE_LL_TX_LLCP_BUF_NB=3,OM6627X=0,
  c include: ../config;../../../common/include;../../../common/source;../../../components/manu_system/fault_handle;../../../components/om_log;../../../components/nvds;../../../components/evt;../../../components/ble/include;../../../components/ble/controller/include;../../../components/ble/host/include;../../../components/ble/profile/om_ancs;../../../components/ble/profile/om_bms;../../../components/ble/profile/om_cgms;../../../components/ble/profile/om_dfu;../../../components/ble/profile/om_gap_dis_batt;../../../components/ble/profile/om_hid_media;../../../components/ble/profile/om_tspp;../../../components/ble/profile/om_wechat_lite;../../../components/pm;../../../hal/CMSIS/Core/Include;../../../hal/driver/include;../../../hal/device/include;../../../rtos/include;../../../rtos/FreeRTOS/Source/Include;../../../rtos/FreeRTOS/CMSIS/Include;../../../rtos/FreeRTOS/CMSIS/Include1;../../../rtos/FreeRTOS/CMSIS/Config/ARMCM;../../../rtos/FreeRTOS/Source/Portable/GCC;..\Source;..\Source\HW;..\JSON\include;..\m_drive\LittleFs\littlefs-2.2.1;..\m_drive\LittleFs\RTC;..\m_drive\m_motor;..\m_drive\m_audio\speaker_audio;..\m_drive\sensor_task\imu;..\m_drive\battery;..\m_drive\m_led;..\m_drive\sensor_task;..\..\..\components\shell;..\m_drive\m_geofence;..\m_drive\m_wifihome;..\pet_behavior_lib_keil_ac6_v2.0.1\include;..\pet_behavior_lib_keil_ac6_v2.0.1\lib\keil\ac6\cortex-m4f-hardfp;..\m_drive\m_audio\mic_audio
  asm define: CONFIG_BLE_HOST,CONFIG_LE_BROADCASTER=1,CONFIG_LE_PERIPHERAL=1,CONFIG_LE_ACTIVITY_NB=2,CONFIG_LE_CONNECTION_NB=1,CONFIG_LE_WHITELIST_NB=6,CONFIG_LE_LL_HCI_CMD_PKTS_NB=2,CONFIG_LE_LL_RX_DATA_BUF_NB=3,CONFIG_LE_LL_RX_DATA_BUF_SIZE=256,CONFIG_LE_LL_TX_ACL_BUF_NB=3,CONFIG_LE_LL_TX_ACL_BUF_SIZE=256,CONFIG_LE_LL_TX_ADV_BUF_NB=2,CONFIG_LE_LL_TX_ADV_FRAG_NB=1,CONFIG_LE_LL_TX_ADV_FRAG_BUF_SIZE=37,CONFIG_LE_LL_TX_LLCP_BUF_NB=3,OM6627X=1,
  asm include: ../config;../../../bsp/include;../../../common/include;../../../common/source;../../../components/manu_system/fault_handle;../../../components/om_log;../../../components/nvds;../../../components/evt;../../../components/ble/include;../../../components/ble/controller/include;../../../components/ble/host/include;../../../components/ble/profile/om_ancs;../../../components/ble/profile/om_bms;../../../components/ble/profile/om_cgms;../../../components/ble/profile/om_dfu;../../../components/ble/profile/om_gap_dis_batt;../../../components/ble/profile/om_hid_media;../../../components/ble/profile/om_tspp;../../../components/ble/profile/om_wechat_lite;../../../components/pm;../../../hal/CMSIS/Core/Include;../../../hal/driver/include;../../../hal/device/include;../../../rtos/include;../../../rtos/FreeRTOS/Source/Include;../../../rtos/FreeRTOS/CMSIS/Include;../../../rtos/FreeRTOS/CMSIS/Include1;../../../rtos/FreeRTOS/CMSIS/Config/ARMCM;../../../rtos/FreeRTOS/Source/Portable/GCC
  library: MicroLIB
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: ../linker_script/Keil/cm4f_flash_ac6.sct
  link misc: --diag_suppress=L6314 --diag_suppress=L6439W
../../../components/ble/controller/lib/ARM/libblectlr_1peripheral.lib
../../../components/ble/host/lib/ARM/libblehost_full.lib
../../../hal/device/ARM/libcpft.lib
  group source
    ../Source/: app_adv.c app_sec.c Assist_Task.c atomic_embedded.c Audio_Task.c Uart_GnssDataRecv_Task.c Uart_Cat1DataRecv_Task.c Test_Task.c system.c stack_monitor_Task.c service_tspp_define.c service_audio.c Sensor_Task.c CAT1_UART_Task.c Comm_Task.c common_def.c entry_task.c evt_task.c pm_Task.c led_task.c main.c GNSS_UART_Task.c ble_state_machine.c ble_op_queue.c audio_mic_task.c
  group m_drive
    ../m_drive/battery/: m_battery.c
    ../m_drive/LittleFs/littlefs-2.2.1/: lfs.c lfs_port.c lfs_util.c lfs_wav.c audio_filename.c audio_storage.c wifi_config_codec.c wifi_config_storage.c
    ../m_drive/LittleFs/RTC/: littlefs_time_rtc.c
    ../m_drive/LittleFs/TimDelay/: littlefs_delay.c
    ../m_drive/m_audio/mic_audio/: app_audio.c codec.lib
    ../m_drive/m_audio/speaker_audio/: my_audio.c test_audio.c
    ../m_drive/m_led/: m_i2c.c
    ../m_drive/m_motor/: m_motor.c
    ../m_drive/sensor_task/imu/: inv_imu_driver.c inv_imu_transport.c inv_imu_apex.c
    ../m_drive/sensor_task/: imu_ex.c pedometer_ex.c spi_ex.c pedometer_counter.c
    ../m_drive/m_geofence/: geofence_runtime.c
    ../m_drive/m_wifihome/: home_mode.c
  group shell
    ../../../components/shell/: shell_common.c shell_port_rtos.c shell_uart_port.c
  group common
    ../../../common/source/: om_printf.c om_mem.c om_ringbuff.c om_common.c om_fifo.c om_libc_retarget.c om_list.c
  group manu_system
    ../../../components/manu_system/fault_handle/: fault_handle.c
  group om_log
    ../../../components/om_log/: om_log.c om_log_port.c
  group nvds
    ../../../components/nvds/: nvds.c
  group evt
    ../../../components/evt/: evt.c evt_timer.c
  group ble_stack_common
    ../../../components/ble/common/: ob_mem_heap.c
  group profile
    ../../../components/ble/profile/om_ancs/: ancs_client.c
    ../../../components/ble/profile/om_bms/: om_bms.c service_om_bms.c
    ../../../components/ble/profile/om_cgms/: om_cgms.c service_om_cgms.c
    ../../../components/ble/profile/om_dfu/: om_dfu.c om_dfu_nvds.c om_dfu_ver_check.c service_om_dfu.c
    ../../../components/ble/profile/om_gap_dis_batt/: service_common.c
    ../../../components/ble/profile/om_hid_media/: app_hid_media.c
    ../../../components/ble/profile/om_tspp/: service_tspp.c
    ../../../components/ble/profile/om_wechat_lite/: app_wechat_lite.c
  group pm
    ../../../components/pm/: pm.c pm_cpu_gnu.S
  group driver
    ../../../hal/driver/source/: drv_mpu.c drv_om24g.c drv_gpadc.c drv_aes.c drv_calib_repair.c drv_calib.c drv_gpdma.c drv_efuse.c drv_gpio.c drv_i2c.c drv_isr.c drv_lptim.c drv_pin.c drv_pmu_timer.c drv_pmu.c drv_radio.c drv_rcc.c drv_rng.c drv_rtc.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c drv_i2s.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_lcd.c drv_irtx.c drv_sha256.c drv_ospi.c drv_psram.c drv_qdec.c drv_rgb.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
    ../../../hal/driver/source/drv_flash/: drv_iflash.c drv_oflash.c drv_flash.c
  group startup
    ../../../hal/device/: system_cm4f.c
    ../../../hal/device/GCC/: startup_cm4f.S
  group FreeRTOS
    ../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../rtos/FreeRTOS/Source/Portable/MemMang/: heap_5.c
    ../../../rtos/FreeRTOS/Source/Portable/Common/: mpu_wrappers.c
    ../../../rtos/FreeRTOS/CMSIS/Source/: cmsis_os2.c cmsis_os1.c freertos_evr.c os_systick.c
    ../../../rtos/FreeRTOS/Source/Portable/GCC/: port.c
  group HW
    ../Source/HW/: board_define.c
  group JSON
    ../JSON/src/: cJSON.c
  group pet_behavior_lib
    ../pet_behavior_lib_keil_ac6_v2.0.1/lib/keil/ac6/cortex-m4f-hardfp/: libpet_behavior.a
    ../pet_behavior_lib_keil_ac6_v2.0.1/include/: pet_behavior_ai.h
