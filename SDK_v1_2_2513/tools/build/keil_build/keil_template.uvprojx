# Keil uVision project keil_template.uvprojx, settings and files
target  (6140000::V6.14::ARMCLANG)
  output: keil_template
  AfterMake: fromelf.exe --bin --output "@L.bin" "#L"
  AfterMake: fromelf.exe -c --output ".\_build\@L.dis" "#L"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
