# IAR project ble_app_mesh.ewp, settings and files
configuration ble_app_mesh (ARM, debug)
  General.OGChipSelectEditMenu: OM6627X Onmicro OM6627X
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 67
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_BLE_HOST; CONFIG_LE_BROADCASTER=1; CONFIG_LE_OBSERVER=1; CONFIG_LE_PERIPHERAL=1; CONFIG_LE_CENTRAL=1; CONFIG_LE_ACTIVITY_NB=10; CONFIG_LE_CONNECTION_NB=8; CONFIG_LE_WHITELIST_NB=6; CONFIG_LE_LL_HCI_CMD_PKTS_NB=2; CONFIG_LE_LL_RX_DATA_BUF_NB=3; CONFIG_LE_LL_RX_DATA_BUF_SIZE=256; CONFIG_LE_LL_TX_ACL_BUF_NB=3; CONFIG_LE_LL_TX_ACL_BUF_SIZE=256; CONFIG_LE_LL_TX_ADV_BUF_NB=5; CONFIG_LE_LL_TX_ADV_FRAG_NB=2; CONFIG_LE_LL_TX_ADV_FRAG_BUF_SIZE=254; CONFIG_LE_LL_TX_LLCP_BUF_NB=11; OM6627X=1
  ICCARM.CCDiagSuppress: Pe111,Pe177,Pe128,Ta022,Ta023
  ICCARM.CCIncludePath2: ../config; ../app; ../app/firms; ../app/tmall; ../../../bsp/include; ../../../common/include; ../../../common/source; ../../../components/shell; ../../../components/manu_system/fault_handle; ../../../components/om_log; ../../../components/nvds; ../../../components/evt; ../../../components/ble/include; ../../../components/ble/controller/include; ../../../components/ble/host/include; ../../../components/ble/profile/om_ancs; ../../../components/ble/profile/om_bms; ../../../components/ble/profile/om_cgms; ../../../components/ble/profile/om_dfu; ../../../components/ble/profile/om_gap_dis_batt; ../../../components/ble/profile/om_hid_media; ../../../components/ble/profile/om_tspp; ../../../components/ble/profile/om_wechat_lite; ../../../components/ble/mesh/include; ../../../components/pm; ../../../hal/CMSIS/Core/Include; ../../../hal/driver/include; ../../../hal/device/include; ../../../rtos/include; ../../../rtos/FreeRTOS/Source/Include; ../../../rtos/FreeRTOS/CMSIS/Include; ../../../rtos/FreeRTOS/CMSIS/Include1; ../../../rtos/FreeRTOS/CMSIS/Config/ARMCM; ../../../rtos/FreeRTOS/Source/Portable/IAR
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ../\ble_app_mesh.bin
  ILINK.IlinkOutputFile: ble_app_mesh.out
  ILINK.IlinkIcfFile: ../linker_script/IAR/cm4f_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../components/ble/controller/lib/IAR/libblectlr_full.a; ../../../components/ble/host/lib/IAR/libblehost_full.a; ../../../components/ble/mesh/lib/IAR/libblemesh.a; ../../../hal/device/IAR/libcpft.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group main
    ../main/: main.c
  group app
    ../app/: omsh_app.c omsh_app_shell.c omsh_app_hook.c
    ../app/firms/: omsh_app_firms.c omsh_app_firms_mdl.c omsh_app_firms_mdl_demo.c
    ../app/tmall/: omsh_app_tmall.c
  group bsp
    ../../../bsp/board_evb/: board_evb.c
  group common
    ../../../common/source/: om_printf.c om_mem.c om_ringbuff.c om_common.c om_fifo.c om_libc_retarget.c om_list.c
  group shell
    ../../../components/shell/: shell_common.c shell_port_rtos.c
  group manu_system
    ../../../components/manu_system/fault_handle/: fault_handle.c
  group om_log
    ../../../components/om_log/: om_log.c om_log_port.c
  group nvds
    ../../../components/nvds/: nvds.c
  group evt
    ../../../components/evt/: evt.c evt_timer.c
  group ble_stack_common
    ../../../components/ble/common/: ob_mem_heap.c
  group profile
    ../../../components/ble/profile/om_ancs/: ancs_client.c
    ../../../components/ble/profile/om_bms/: om_bms.c service_om_bms.c
    ../../../components/ble/profile/om_cgms/: om_cgms.c service_om_cgms.c
    ../../../components/ble/profile/om_dfu/: om_dfu.c om_dfu_nvds.c om_dfu_ver_check.c service_om_dfu.c
    ../../../components/ble/profile/om_gap_dis_batt/: service_common.c
    ../../../components/ble/profile/om_hid_media/: app_hid_media.c
    ../../../components/ble/profile/om_tspp/: service_tspp.c
    ../../../components/ble/profile/om_wechat_lite/: app_wechat_lite.c
  group pm
    ../../../components/pm/: pm.c pm_cpu_iar.S
  group driver
    ../../../hal/driver/source/: drv_mpu.c drv_om24g.c drv_gpadc.c drv_aes.c drv_calib_repair.c drv_calib.c drv_gpdma.c drv_efuse.c drv_gpio.c drv_i2c.c drv_isr.c drv_lptim.c drv_pin.c drv_pmu_timer.c drv_pmu.c drv_radio.c drv_rcc.c drv_rng.c drv_rtc.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c drv_i2s.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_lcd.c drv_irtx.c drv_sha256.c drv_ospi.c drv_psram.c drv_qdec.c drv_rgb.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
    ../../../hal/driver/source/drv_flash/: drv_iflash.c drv_oflash.c drv_flash.c
  group startup
    ../../../hal/device/: system_cm4f.c
    ../../../hal/device/IAR/: startup_cm4f.S
  group FreeRTOS
    ../../../rtos/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../rtos/FreeRTOS/Source/Portable/MemMang/: heap_5.c
    ../../../rtos/FreeRTOS/Source/Portable/Common/: mpu_wrappers.c
    ../../../rtos/FreeRTOS/CMSIS/Source/: cmsis_os2.c cmsis_os1.c freertos_evr.c os_systick.c
    ../../../rtos/FreeRTOS/Source/Portable/IAR/: port.c portasm.s
