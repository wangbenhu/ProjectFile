# IAR project example.ewp, settings and files
configuration example (ARM, debug)
  General.OGChipSelectEditMenu: OM6627X Onmicro OM6627X
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 67
  General.FPU2: 4
  ICCARM.CCDefines: OM6627X=1
  ICCARM.CCDiagSuppress: Pe111,Pe177,Pe128,Ta022,Ta023
  ICCARM.CCIncludePath2: ../config; ../drv_example; ../../../bsp/include; ../../../common/include; ../../../common/source; ../../../components/om_log; ../../../components/nvds; ../../../components/pm; ../../../hal/CMSIS/Core/Include; ../../../hal/driver/include; ../../../hal/device/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: OM6627X=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ../\example.bin
  ILINK.IlinkOutputFile: example.out
  ILINK.IlinkIcfFile: ../linker_script/IAR/cm4f_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../hal/device/IAR/libcpft.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group main
    ../main/: main.c
  group drv_example
    ../drv_example/: example_aes.c example_audio.c example_efuse.c example_flash.c example_gpadc.c example_gpdma.c example_gpio.c example_i2c.c example_i2s.c example_ir.c example_lcd.c example_lptimer.c example_pmu_timer.c example_qdec.c example_rgb.c example_rtc.c example_spi.c example_timer.c example_uart.c example_wdt.c example_shelf_mode.c
  group bsp
    ../../../bsp/board_evb/: board_evb.c
    ../../../bsp/source/: glcd_gc9c01.c
  group common
    ../../../common/source/: om_printf.c om_mem.c om_ringbuff.c om_common.c om_fifo.c om_libc_retarget.c om_list.c
  group om_log
    ../../../components/om_log/: om_log.c om_log_port.c
  group nvds
    ../../../components/nvds/: nvds.c
  group pm
    ../../../components/pm/: pm.c
  group driver
    ../../../hal/driver/source/: drv_mpu.c drv_om24g.c drv_gpadc.c drv_aes.c drv_calib_repair.c drv_calib.c drv_gpdma.c drv_efuse.c drv_gpio.c drv_i2c.c drv_isr.c drv_lptim.c drv_pin.c drv_pmu_timer.c drv_pmu.c drv_radio.c drv_rcc.c drv_rng.c drv_rtc.c drv_spi.c drv_tim.c drv_uart.c drv_wdt.c drv_i2s.c drv_audio.c drv_audio_inside.c drv_audio_outside.c drv_lcd.c drv_irtx.c drv_sha256.c drv_ospi.c drv_psram.c drv_qdec.c drv_rgb.c
    ../../../hal/driver/source/drv_ecdsa/: drv_ecdsa.c
    ../../../hal/driver/source/drv_ecdsa/uECC/: uECC.c
    ../../../hal/driver/source/drv_flash/: drv_iflash.c drv_oflash.c drv_flash.c
  group startup
    ../../../hal/device/: system_cm4f.c
    ../../../hal/device/IAR/: startup_cm4f.S
