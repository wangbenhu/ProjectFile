/* ----------------------------------------------------------------------------
 * All rights reserved.
 *
 * This software is licensed under terms that can be found in the LICENSE file
 * in the root directory of this software component.
 * If no LICENSE file comes with this software, it is provided AS-IS.
 * -------------------------------------------------------------------------- */

/**
 * @defgroup DOC DOC
 * @ingroup  DOCUMENT
 * @brief    example for using aes
 * @details  example for using aes:
 * @version
 *
 * Version 1.0
 *  - Initial release
 *
 * @{
 */


/*******************************************************************************
 * INCLUDES
 */
#include "om_driver.h"


/*******************************************************************************
 * MACROS
 */


/*******************************************************************************
 * TYPEDEFS
 */


/*******************************************************************************
 * CONST & VARIABLES
 */
static const unsigned char aes_test_ecb_dec[][16] = {
    { 0x44, 0x41, 0x6A, 0xC2, 0xD1, 0xF5, 0x3C, 0x58,
      0x33, 0x03, 0x91, 0x7E, 0x6B, 0xE9, 0xEB, 0xE0 },
    { 0x48, 0xE3, 0x1E, 0x9E, 0x25, 0x67, 0x18, 0xF2,
      0x92, 0x29, 0x31, 0x9C, 0x19, 0xF1, 0x5B, 0xA4 },
    { 0x05, 0x8C, 0xCF, 0xFD, 0xBB, 0xCB, 0x38, 0x2D,
      0x1F, 0x6F, 0x56, 0x58, 0x5D, 0x8A, 0x4A, 0xDE }
};

static const unsigned char aes_test_ecb_enc[][16] = {
    { 0xC3, 0x4C, 0x05, 0x2C, 0xC0, 0xDA, 0x8D, 0x73,
      0x45, 0x1A, 0xFE, 0x5F, 0x03, 0xBE, 0x29, 0x7F },
    { 0xF3, 0xF6, 0x75, 0x2A, 0xE8, 0xD7, 0x83, 0x11,
      0x38, 0xF0, 0x41, 0x56, 0x06, 0x31, 0xB1, 0x14 },
    { 0x8B, 0x79, 0xEE, 0xCC, 0x93, 0xA0, 0xEE, 0x5D,
      0xFF, 0x30, 0xB4, 0xEA, 0x21, 0x63, 0x6D, 0xA4 }
};

static const unsigned char aes_test_cbc_dec[][16] = {
    { 0xFA, 0xCA, 0x37, 0xE0, 0xB0, 0xC8, 0x53, 0x73,
      0xDF, 0x70, 0x6E, 0x73, 0xF7, 0xC9, 0xAF, 0x86 },
    { 0x5D, 0xF6, 0x78, 0xDD, 0x17, 0xBA, 0x4E, 0x75,
      0xB6, 0x17, 0x68, 0xC6, 0xAD, 0xEF, 0x7C, 0x7B },
    { 0x48, 0x04, 0xE1, 0x81, 0x8F, 0xE6, 0x29, 0x75,
      0x19, 0xA3, 0xE8, 0x8C, 0x57, 0x31, 0x04, 0x13 }
};

static const unsigned char aes_test_cbc_enc[][16] = {
    { 0x8A, 0x05, 0xFC, 0x5E, 0x09, 0x5A, 0xF4, 0x84,
      0x8A, 0x08, 0xD3, 0x28, 0xD3, 0x68, 0x8E, 0x3D },
    { 0x7B, 0xD9, 0x66, 0xD5, 0x3A, 0xD8, 0xC1, 0xBB,
      0x85, 0xD2, 0xAD, 0xFA, 0xE8, 0x7B, 0xB1, 0x04 },
    { 0xFE, 0x3C, 0x53, 0x65, 0x3E, 0x2F, 0x45, 0xB5,
      0x6F, 0xCD, 0x88, 0xB2, 0xCC, 0x89, 0x8F, 0xF0 }
};

static const unsigned char aes_test_cfb128_key[][32] = {
    { 0x2B, 0x7E, 0x15, 0x16, 0x28, 0xAE, 0xD2, 0xA6,
      0xAB, 0xF7, 0x15, 0x88, 0x09, 0xCF, 0x4F, 0x3C },
    { 0x8E, 0x73, 0xB0, 0xF7, 0xDA, 0x0E, 0x64, 0x52,
      0xC8, 0x10, 0xF3, 0x2B, 0x80, 0x90, 0x79, 0xE5,
      0x62, 0xF8, 0xEA, 0xD2, 0x52, 0x2C, 0x6B, 0x7B },
    { 0x60, 0x3D, 0xEB, 0x10, 0x15, 0xCA, 0x71, 0xBE,
      0x2B, 0x73, 0xAE, 0xF0, 0x85, 0x7D, 0x77, 0x81,
      0x1F, 0x35, 0x2C, 0x07, 0x3B, 0x61, 0x08, 0xD7,
      0x2D, 0x98, 0x10, 0xA3, 0x09, 0x14, 0xDF, 0xF4 }
};

static const unsigned char aes_test_cfb128_iv[16] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F
};

static const unsigned char aes_test_cfb128_pt[64] = {
    0x6B, 0xC1, 0xBE, 0xE2, 0x2E, 0x40, 0x9F, 0x96,
    0xE9, 0x3D, 0x7E, 0x11, 0x73, 0x93, 0x17, 0x2A,
    0xAE, 0x2D, 0x8A, 0x57, 0x1E, 0x03, 0xAC, 0x9C,
    0x9E, 0xB7, 0x6F, 0xAC, 0x45, 0xAF, 0x8E, 0x51,
    0x30, 0xC8, 0x1C, 0x46, 0xA3, 0x5C, 0xE4, 0x11,
    0xE5, 0xFB, 0xC1, 0x19, 0x1A, 0x0A, 0x52, 0xEF,
    0xF6, 0x9F, 0x24, 0x45, 0xDF, 0x4F, 0x9B, 0x17,
    0xAD, 0x2B, 0x41, 0x7B, 0xE6, 0x6C, 0x37, 0x10
};

static const unsigned char aes_test_cfb128_ct[][64] = {
    { 0x3B, 0x3F, 0xD9, 0x2E, 0xB7, 0x2D, 0xAD, 0x20,
      0x33, 0x34, 0x49, 0xF8, 0xE8, 0x3C, 0xFB, 0x4A,
      0xC8, 0xA6, 0x45, 0x37, 0xA0, 0xB3, 0xA9, 0x3F,
      0xCD, 0xE3, 0xCD, 0xAD, 0x9F, 0x1C, 0xE5, 0x8B,
      0x26, 0x75, 0x1F, 0x67, 0xA3, 0xCB, 0xB1, 0x40,
      0xB1, 0x80, 0x8C, 0xF1, 0x87, 0xA4, 0xF4, 0xDF,
      0xC0, 0x4B, 0x05, 0x35, 0x7C, 0x5D, 0x1C, 0x0E,
      0xEA, 0xC4, 0xC6, 0x6F, 0x9F, 0xF7, 0xF2, 0xE6 },
    { 0xCD, 0xC8, 0x0D, 0x6F, 0xDD, 0xF1, 0x8C, 0xAB,
      0x34, 0xC2, 0x59, 0x09, 0xC9, 0x9A, 0x41, 0x74,
      0x67, 0xCE, 0x7F, 0x7F, 0x81, 0x17, 0x36, 0x21,
      0x96, 0x1A, 0x2B, 0x70, 0x17, 0x1D, 0x3D, 0x7A,
      0x2E, 0x1E, 0x8A, 0x1D, 0xD5, 0x9B, 0x88, 0xB1,
      0xC8, 0xE6, 0x0F, 0xED, 0x1E, 0xFA, 0xC4, 0xC9,
      0xC0, 0x5F, 0x9F, 0x9C, 0xA9, 0x83, 0x4F, 0xA0,
      0x42, 0xAE, 0x8F, 0xBA, 0x58, 0x4B, 0x09, 0xFF },
    { 0xDC, 0x7E, 0x84, 0xBF, 0xDA, 0x79, 0x16, 0x4B,
      0x7E, 0xCD, 0x84, 0x86, 0x98, 0x5D, 0x38, 0x60,
      0x39, 0xFF, 0xED, 0x14, 0x3B, 0x28, 0xB1, 0xC8,
      0x32, 0x11, 0x3C, 0x63, 0x31, 0xE5, 0x40, 0x7B,
      0xDF, 0x10, 0x13, 0x24, 0x15, 0xE5, 0x4B, 0x92,
      0xA1, 0x3E, 0xD0, 0xA8, 0x26, 0x7A, 0xE2, 0xF9,
      0x75, 0xA3, 0x85, 0x74, 0x1A, 0xB9, 0xCE, 0xF8,
      0x20, 0x31, 0x62, 0x3D, 0x55, 0xB1, 0xE4, 0x71 }
};

static const unsigned char aes_test_ofb_key[][32] = {
    { 0x2B, 0x7E, 0x15, 0x16, 0x28, 0xAE, 0xD2, 0xA6,
      0xAB, 0xF7, 0x15, 0x88, 0x09, 0xCF, 0x4F, 0x3C },
    { 0x8E, 0x73, 0xB0, 0xF7, 0xDA, 0x0E, 0x64, 0x52,
      0xC8, 0x10, 0xF3, 0x2B, 0x80, 0x90, 0x79, 0xE5,
      0x62, 0xF8, 0xEA, 0xD2, 0x52, 0x2C, 0x6B, 0x7B },
    { 0x60, 0x3D, 0xEB, 0x10, 0x15, 0xCA, 0x71, 0xBE,
      0x2B, 0x73, 0xAE, 0xF0, 0x85, 0x7D, 0x77, 0x81,
      0x1F, 0x35, 0x2C, 0x07, 0x3B, 0x61, 0x08, 0xD7,
      0x2D, 0x98, 0x10, 0xA3, 0x09, 0x14, 0xDF, 0xF4 }
};

static const unsigned char aes_test_ofb_iv[16] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F
};

static const unsigned char aes_test_ofb_pt[64] = {
    0x6B, 0xC1, 0xBE, 0xE2, 0x2E, 0x40, 0x9F, 0x96,
    0xE9, 0x3D, 0x7E, 0x11, 0x73, 0x93, 0x17, 0x2A,
    0xAE, 0x2D, 0x8A, 0x57, 0x1E, 0x03, 0xAC, 0x9C,
    0x9E, 0xB7, 0x6F, 0xAC, 0x45, 0xAF, 0x8E, 0x51,
    0x30, 0xC8, 0x1C, 0x46, 0xA3, 0x5C, 0xE4, 0x11,
    0xE5, 0xFB, 0xC1, 0x19, 0x1A, 0x0A, 0x52, 0xEF,
    0xF6, 0x9F, 0x24, 0x45, 0xDF, 0x4F, 0x9B, 0x17,
    0xAD, 0x2B, 0x41, 0x7B, 0xE6, 0x6C, 0x37, 0x10
};

static const unsigned char aes_test_ofb_ct[][64] = {
    { 0x3B, 0x3F, 0xD9, 0x2E, 0xB7, 0x2D, 0xAD, 0x20,
      0x33, 0x34, 0x49, 0xF8, 0xE8, 0x3C, 0xFB, 0x4A,
      0x77, 0x89, 0x50, 0x8d, 0x16, 0x91, 0x8f, 0x03,
      0xf5, 0x3c, 0x52, 0xda, 0xc5, 0x4e, 0xd8, 0x25,
      0x97, 0x40, 0x05, 0x1e, 0x9c, 0x5f, 0xec, 0xf6,
      0x43, 0x44, 0xf7, 0xa8, 0x22, 0x60, 0xed, 0xcc,
      0x30, 0x4c, 0x65, 0x28, 0xf6, 0x59, 0xc7, 0x78,
      0x66, 0xa5, 0x10, 0xd9, 0xc1, 0xd6, 0xae, 0x5e },
    { 0xCD, 0xC8, 0x0D, 0x6F, 0xDD, 0xF1, 0x8C, 0xAB,
      0x34, 0xC2, 0x59, 0x09, 0xC9, 0x9A, 0x41, 0x74,
      0xfc, 0xc2, 0x8b, 0x8d, 0x4c, 0x63, 0x83, 0x7c,
      0x09, 0xe8, 0x17, 0x00, 0xc1, 0x10, 0x04, 0x01,
      0x8d, 0x9a, 0x9a, 0xea, 0xc0, 0xf6, 0x59, 0x6f,
      0x55, 0x9c, 0x6d, 0x4d, 0xaf, 0x59, 0xa5, 0xf2,
      0x6d, 0x9f, 0x20, 0x08, 0x57, 0xca, 0x6c, 0x3e,
      0x9c, 0xac, 0x52, 0x4b, 0xd9, 0xac, 0xc9, 0x2a },
    { 0xDC, 0x7E, 0x84, 0xBF, 0xDA, 0x79, 0x16, 0x4B,
      0x7E, 0xCD, 0x84, 0x86, 0x98, 0x5D, 0x38, 0x60,
      0x4f, 0xeb, 0xdc, 0x67, 0x40, 0xd2, 0x0b, 0x3a,
      0xc8, 0x8f, 0x6a, 0xd8, 0x2a, 0x4f, 0xb0, 0x8d,
      0x71, 0xab, 0x47, 0xa0, 0x86, 0xe8, 0x6e, 0xed,
      0xf3, 0x9d, 0x1c, 0x5b, 0xba, 0x97, 0xc4, 0x08,
      0x01, 0x26, 0x14, 0x1d, 0x67, 0xf3, 0x7b, 0xe8,
      0x53, 0x8f, 0x5a, 0x8b, 0xe7, 0x40, 0xe4, 0x84 }
};

static const unsigned char aes_test_ctr_key[][16] = {
    { 0xAE, 0x68, 0x52, 0xF8, 0x12, 0x10, 0x67, 0xCC,
      0x4B, 0xF7, 0xA5, 0x76, 0x55, 0x77, 0xF3, 0x9E },
    { 0x7E, 0x24, 0x06, 0x78, 0x17, 0xFA, 0xE0, 0xD7,
      0x43, 0xD6, 0xCE, 0x1F, 0x32, 0x53, 0x91, 0x63 },
    { 0x76, 0x91, 0xBE, 0x03, 0x5E, 0x50, 0x20, 0xA8,
      0xAC, 0x6E, 0x61, 0x85, 0x29, 0xF9, 0xA0, 0xDC }
};

static const unsigned char aes_test_ctr_nonce_counter[][16] = {
    { 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
      0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01 },
    { 0x00, 0x6C, 0xB6, 0xDB, 0xC0, 0x54, 0x3B, 0x59,
      0xDA, 0x48, 0xD9, 0x0B, 0x00, 0x00, 0x00, 0x01 },
    { 0x00, 0xE0, 0x01, 0x7B, 0x27, 0x77, 0x7F, 0x3F,
      0x4A, 0x17, 0x86, 0xF0, 0x00, 0x00, 0x00, 0x01 }
};

static const unsigned char aes_test_ctr_pt[][48] = {
    { 0x53, 0x69, 0x6E, 0x67, 0x6C, 0x65, 0x20, 0x62,
      0x6C, 0x6F, 0x63, 0x6B, 0x20, 0x6D, 0x73, 0x67 },
    { 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
      0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F,
      0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
      0x18, 0x19, 0x1A, 0x1B, 0x1C, 0x1D, 0x1E, 0x1F },
    { 0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
      0x08, 0x09, 0x0A, 0x0B, 0x0C, 0x0D, 0x0E, 0x0F,
      0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
      0x18, 0x19, 0x1A, 0x1B, 0x1C, 0x1D, 0x1E, 0x1F,
      0x20, 0x21, 0x22, 0x23 }
};

static const unsigned char aes_test_ctr_ct[][48] = {
    { 0xE4, 0x09, 0x5D, 0x4F, 0xB7, 0xA7, 0xB3, 0x79,
      0x2D, 0x61, 0x75, 0xA3, 0x26, 0x13, 0x11, 0xB8 },
    { 0x51, 0x04, 0xA1, 0x06, 0x16, 0x8A, 0x72, 0xD9,
      0x79, 0x0D, 0x41, 0xEE, 0x8E, 0xDA, 0xD3, 0x88,
      0xEB, 0x2E, 0x1E, 0xFC, 0x46, 0xDA, 0x57, 0xC8,
      0xFC, 0xE6, 0x30, 0xDF, 0x91, 0x41, 0xBE, 0x28 },
    { 0xC1, 0xCF, 0x48, 0xA8, 0x9F, 0x2F, 0xFD, 0xD9,
      0xCF, 0x46, 0x52, 0xE9, 0xEF, 0xDB, 0x72, 0xD7,
      0x45, 0x40, 0xA4, 0x2B, 0xDE, 0x6D, 0x78, 0x36,
      0xD5, 0x9A, 0x5C, 0xEA, 0xAE, 0xF3, 0x10, 0x53,
      0x25, 0xB2, 0x07, 0x2F }
};

static const int aes_test_ctr_len[3] = { 16, 32, 36 };

static const unsigned char aes_test_gcm_key[16] = {
    0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0,
    0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0
};

static const unsigned char aes_test_gcm_iv[12] = {
    0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0, 0x0,
    0x0, 0x0, 0x0, 0x0
};

static const unsigned char aes_test_gcm_add[3] = {
    0xcc, 0xcc, 0xcc
};

static const unsigned char aes_test_gcm_pt[3] = {
    0x0, 0x0, 0x0
};

static const unsigned char aes_test_gcm_ct[3] = {
    0x03, 0x88, 0xda
};

static const unsigned char aes_test_gcm_tag[16] = {
    0xd8, 0x0c, 0x70, 0x70, 0x7b, 0x1b, 0xc2, 0x07,
    0x07, 0x2c, 0x14, 0xc3, 0x69, 0x1c, 0xf7, 0x10,
};

static const unsigned char aes_cmac_128_key[16] = {
    0x2b, 0x7e, 0x15, 0x16, 0x28, 0xae, 0xd2, 0xa6,
    0xab, 0xf7, 0x15, 0x88, 0x09, 0xcf, 0x4f, 0x3c
};

static const unsigned char aes_cmac_message[] = {
    0x6b, 0xc1, 0xbe, 0xe2,     0x2e, 0x40, 0x9f, 0x96,
    0xe9, 0x3d, 0x7e, 0x11,     0x73, 0x93, 0x17, 0x2a,
    0xae, 0x2d, 0x8a, 0x57,     0x1e, 0x03, 0xac, 0x9c,
    0x9e, 0xb7, 0x6f, 0xac,     0x45, 0xaf, 0x8e, 0x51,
    0x30, 0xc8, 0x1c, 0x46,     0xa3, 0x5c, 0xe4, 0x11,
    0xe5, 0xfb, 0xc1, 0x19,     0x1a, 0x0a, 0x52, 0xef,
    0xf6, 0x9f, 0x24, 0x45,     0xdf, 0x4f, 0x9b, 0x17,
    0xad, 0x2b, 0x41, 0x7b,     0xe6, 0x6c, 0x37, 0x10
};

static const unsigned char aes_cmac_128_expected_result[][16] = {
    { 0xbb, 0x1d, 0x69, 0x29,     0xe9, 0x59, 0x37, 0x28,
      0x7f, 0xa3, 0x7d, 0x12,     0x9b, 0x75, 0x67, 0x46 },
    { 0x07, 0x0a, 0x16, 0xb4,     0x6b, 0x4d, 0x41, 0x44,
      0xf7, 0x9b, 0xdd, 0x9d,     0xd0, 0x4a, 0x28, 0x7c },
    { 0x7d, 0x85, 0x44, 0x9e,     0xa6, 0xea, 0x19, 0xc8,
      0x23, 0xa7, 0xbf, 0x78,     0x83, 0x7d, 0xfa, 0xde },
    { 0x51, 0xf0, 0xbe, 0xbf,     0x7e, 0x3b, 0x9d, 0x92,
      0xfc, 0x49, 0x74, 0x17,     0x79, 0x36, 0x3c, 0xfe }
};


/*******************************************************************************
 * LOCAL FUNCTIONS
 */
static bool example_aes_check(const uint8_t *expected, const uint8_t *actual, uint32_t len, const char *name)
{
    if (memcmp(expected, actual, len) != 0) {
        om_printf("%s failed\r\n", name);
        return false;
    }

    return true;
}


/*******************************************************************************
 * PUBLIC FUNCTIONS
 */
/**
 *******************************************************************************
 * @brief example of using aes ecb mode
 *
 *******************************************************************************
 */
void example_aes_ecb(void)
{
    int i, j, u, mode;
    unsigned char key[32];
    unsigned char buf[64];
    const unsigned char *aes_result;
    uint8_t num_tests;
    aes_ecb_config_t ecb_cfg;

    num_tests = sizeof(aes_test_ecb_enc) / sizeof(*aes_test_ecb_enc);
    memset(key, 0, 32);

    for (i = 0; i < num_tests << 1; i++) {
        u = i >> 1;
        mode = i & 1;
        memset(buf, 0, 16);
        aes_result = (mode == AES_OP_DECRYPT) ? aes_test_ecb_dec[u] : aes_test_ecb_enc[u];
        memcpy(ecb_cfg.key, key, sizeof(key));
        ecb_cfg.keybits = (aes_keybits_t)u;
        ecb_cfg.operation = (aes_operation_t)mode;
        drv_aes_ecb_start(OM_AES0, &ecb_cfg);
        for (j = 0; j < 10000; j++) {
            drv_aes_ecb_crypt_continue(OM_AES0, buf, buf, 16);
        }
        drv_aes_ecb_crypt_stop(OM_AES0);
        if (!example_aes_check(aes_result, buf, 16, "AES ECB mode test")) {
            return;
        }
    }

    om_printf("AES ECB mode test success\r\n");
}

/**
 *******************************************************************************
 * @brief example of using aes cbc mode
 *
 *******************************************************************************
 */
void example_aes_cbc(void)
{
    int i, j, u, mode;
    unsigned char key[32];
    unsigned char buf[64];
    const unsigned char *aes_result;
    unsigned char iv[16];
    unsigned char prv[16];
    uint8_t num_tests;
    aes_cbc_config_t cbc_cfg;

    DRV_RCC_CLOCK_ENABLE(RCC_CLK_BLE, 1);
    REGW(&OM_PMU->MISC_CTRL, MASK_4REG(PMU_MISC_CTRL_BB_1_RESET, 0, PMU_MISC_CTRL_BB_2_RESET, 0,
                                       PMU_MISC_CTRL_BB_2_APB_RESET, 0, PMU_MISC_CTRL_BB_32K_SOFT_RSTN, 1));

    num_tests = sizeof(aes_test_cbc_dec) / sizeof(*aes_test_cbc_dec);
    memset(key, 0, 32);

    for (i = 0; i < num_tests << 1; i++) {
        u = i >> 1;
        mode = i & 1;
        memset(iv, 0, 16);
        memset(prv, 0, 16);
        memset(buf, 0, 16);
        aes_result = (mode == AES_OP_DECRYPT) ? aes_test_cbc_dec[u] : aes_test_cbc_enc[u];
        memcpy(cbc_cfg.key, key, sizeof(key));
        memcpy(cbc_cfg.iv, iv, sizeof(iv));
        cbc_cfg.keybits = (aes_keybits_t)u;
        cbc_cfg.operation = (aes_operation_t)mode;
        drv_aes_cbc_start(OM_AES0, &cbc_cfg);
        for (j = 0; j < 10000; j++) {
            if (mode == AES_OP_ENCRYPT) {
                uint8_t tmp[16];
                memcpy(tmp, prv, 16);
                memcpy(prv, buf, 16);
                memcpy(buf, tmp, 16);
            }
            drv_aes_cbc_crypt_continue(OM_AES0, buf, buf, 16);
        }
        drv_aes_cbc_crypt_stop(OM_AES0);
        if (!example_aes_check(aes_result, buf, 16, "AES CBC mode test")) {
            return;
        }
    }

    om_printf("AES CBC mode test success\r\n");
}

/**
 *******************************************************************************
 * @brief example of using aes cfb mode
 *
 *******************************************************************************
 */
void example_aes_cfb(void)
{
    int i, u, mode;
    unsigned int keybits;
    unsigned char buf[64];
    const unsigned char *aes_result;
    uint8_t num_tests;
    aes_cfb_config_t cfb_cfg;

    num_tests = sizeof(aes_test_cfb128_key) / sizeof(*aes_test_cfb128_key);

    for (i = 0; i < num_tests << 1; i++) {
        u = i >> 1;
        keybits = 128 + u * 64;
        mode = i & 1;
        if (mode == AES_OP_DECRYPT) {
            memcpy(buf, aes_test_cfb128_ct[u], 64);
            aes_result = aes_test_cfb128_pt;
        } else {
            memcpy(buf, aes_test_cfb128_pt, 64);
            aes_result = aes_test_cfb128_ct[u];
        }
        memcpy(cfb_cfg.iv,  aes_test_cfb128_iv, 16);
        memcpy(cfb_cfg.key, aes_test_cfb128_key[u], keybits / 8);
        cfb_cfg.keybits = (aes_keybits_t)u;
        cfb_cfg.operation = (aes_operation_t)mode;
        cfb_cfg.iv_offset = 0;
        drv_aes_cfb_start(OM_AES0, &cfb_cfg);
        drv_aes_cfb_crypt_continue(OM_AES0, buf, buf, 64);
        drv_aes_cfb_crypt_stop(OM_AES0);
        if (!example_aes_check(aes_result, buf, 64, "AES CFB mode test")) {
            return;
        }
    }

    om_printf("AES CFB mode test success\r\n");
}

/**
 *******************************************************************************
 * @brief example of using aes ofb mode
 *
 *******************************************************************************
 */
void example_aes_ofb(void)
{
    int i, u, mode;
    unsigned int keybits;
    unsigned char buf[64];
    const unsigned char *aes_result;
    uint8_t num_tests;
    aes_ofb_config_t ofb_cfg;

    num_tests = sizeof(aes_test_ofb_key) / sizeof(*aes_test_ofb_key);

    for (i = 0; i < num_tests << 1; i++) {
        u = i >> 1;
        keybits = 128 + u * 64;
        mode = i & 1;
        memcpy(ofb_cfg.iv,  aes_test_ofb_iv, 16);
        memcpy(ofb_cfg.key, aes_test_ofb_key[u], keybits / 8);
        ofb_cfg.keybits = (aes_keybits_t)u;
        ofb_cfg.iv_offset = 0;
        if (mode == AES_OP_DECRYPT) {
            memcpy(buf, aes_test_ofb_ct[u], 64);
            aes_result = aes_test_ofb_pt;
        } else {
            memcpy(buf, aes_test_ofb_pt, 64);
            aes_result = aes_test_ofb_ct[u];
        }
        drv_aes_ofb_start(OM_AES0, &ofb_cfg);
        drv_aes_ofb_crypt_continue(OM_AES0, buf, buf, 64);
        drv_aes_ofb_crypt_stop(OM_AES0);
        if (!example_aes_check(aes_result, buf, 64, "AES OFB mode test")) {
            return;
        }
    }

    om_printf("AES OFB mode test success\r\n");
}

/**
 *******************************************************************************
 * @brief example of using aes ctr mode
 *
 *******************************************************************************
 */
void example_aes_ctr(void)
{
    int i, u, mode;
    unsigned char buf[64];
    const unsigned char *aes_result;
    uint8_t len;
    uint8_t num_tests;
    aes_ctr_config_t ctr_cfg;

    num_tests = sizeof(aes_test_ctr_key) / sizeof(*aes_test_ctr_key);

    for (i = 0; i < num_tests << 1; i++) {
        u = i >> 1;
        mode = i & 1;
        ctr_cfg.nc_offset = 0;
        ctr_cfg.keybits   = AES_KEYBITS_128;
        memcpy(ctr_cfg.key, aes_test_ctr_key[u], 16);
        memcpy(ctr_cfg.nonce_counter, aes_test_ctr_nonce_counter[u], 16);
        len = (uint8_t)aes_test_ctr_len[u];
        if (mode == AES_OP_DECRYPT) {
            memcpy(buf, aes_test_ctr_ct[u], len);
            aes_result = aes_test_ctr_pt[u];
        } else {
            memcpy(buf, aes_test_ctr_pt[u], len);
            aes_result = aes_test_ctr_ct[u];
        }
        drv_aes_ctr_start(OM_AES0, &ctr_cfg);
        drv_aes_ctr_crypt_continue(OM_AES0, buf, buf, len);
        drv_aes_ctr_crypt_stop(OM_AES0);
        if (!example_aes_check(aes_result, buf, len, "AES CTR mode test")) {
            return;
        }
    }

    om_printf("AES CTR mode test success\r\n");
}

/**
 *******************************************************************************
 * @brief example of using aes gcm mode
 *
 *******************************************************************************
 */
void example_aes_gcm(void)
{
    aes_gcm_config_t gcm_cfg;
    uint8_t cipher_text[3];
    uint8_t plain_text[3];
    uint8_t tag[16];

    gcm_cfg.gcm_operation = GCM_OP_ENCRYPT;
    gcm_cfg.keybits = AES_KEYBITS_128;
    memcpy(gcm_cfg.key, aes_test_gcm_key, 16);
    gcm_cfg.iv_len = 12;
    memcpy(gcm_cfg.iv, aes_test_gcm_iv, 12);
    gcm_cfg.addition_len = sizeof(aes_test_gcm_add);
    gcm_cfg.addition = (uint8_t *)aes_test_gcm_add;
    drv_aes_gcm_start(OM_AES0, &gcm_cfg);
    drv_aes_gcm_crypt_continue(OM_AES0, aes_test_gcm_pt, cipher_text, 3);
    drv_aes_gcm_crypt_stop(OM_AES0, tag, 16);
    if (!example_aes_check(aes_test_gcm_ct, cipher_text, 3, "AES GCM encrypt test")) {
        return;
    }
    if (!example_aes_check(aes_test_gcm_tag, tag, 16, "AES GCM tag test")) {
        return;
    }

    gcm_cfg.gcm_operation = GCM_OP_DECRYPT;
    drv_aes_gcm_start(OM_AES0, &gcm_cfg);
    drv_aes_gcm_crypt_continue(OM_AES0, cipher_text, plain_text, 3);
    drv_aes_gcm_crypt_stop(OM_AES0, tag, 16);
    if (!example_aes_check(aes_test_gcm_pt, plain_text, 3, "AES GCM decrypt test")) {
        return;
    }
    if (!example_aes_check(aes_test_gcm_tag, tag, 16, "AES GCM decrypt tag test")) {
        return;
    }

    om_printf("AES GCM mode test success\r\n");
}

/**
 *******************************************************************************
 * @brief example of using aes ccm le mode
 *
 *******************************************************************************
 */
void example_aes_ccm_le(void)
{
    aes_ccm_le_config_t cfg = {
        .aad   = 0x03,
        .key   = {0x99, 0xad, 0x1b, 0x52, 0x26, 0xa3, 0x7e, 0x3e,
                  0x05, 0x8e, 0x3b, 0x8e, 0x27, 0xc2, 0xc6, 0x66},
        .nonce = {0x00, 0x00, 0x00, 0x00, 0x80, 0x24, 0xab, 0xdc,
                  0xba, 0xbe, 0xba, 0xaf, 0xde}
    };
    uint8_t plain_text[1] = {0x06};
    uint8_t plain_text_actual[1];
    uint8_t cipher_text_and_tag[1 + 4];
    uint8_t cipher_text_and_tag_expect[1 + 4] = {0x9f, 0xcd, 0xa7, 0xf4, 0x48};

    memset(plain_text_actual, 0x0, sizeof(plain_text));
    memset(cipher_text_and_tag, 0x0, sizeof(cipher_text_and_tag));
    if (drv_aes_ccm_le_encrypt(&cfg, plain_text, cipher_text_and_tag, sizeof(plain_text)) != OM_ERROR_OK) {
        om_printf("AES CCM LE encrypt failed\r\n");
        return;
    }
    if (drv_aes_ccm_le_decrypt(&cfg, cipher_text_and_tag, plain_text_actual, sizeof(plain_text)) != OM_ERROR_OK) {
        om_printf("AES CCM LE decrypt failed\r\n");
        return;
    }
    if (!example_aes_check(cipher_text_and_tag_expect, cipher_text_and_tag, sizeof(cipher_text_and_tag), "AES CCM LE encrypt result test")) {
        return;
    }
    if (!example_aes_check(plain_text, plain_text_actual, sizeof(plain_text), "AES CCM LE decrypt result test")) {
        return;
    }

    om_printf("AES CCM LE mode test success\r\n");
}

/**
 *******************************************************************************
 * @brief example of using aes cmac
 *
 *******************************************************************************
 */
void example_aes_cmac(void)
{
    aes_cmac_config_t cfg;
    uint8_t cmac_result[16];
    uint8_t cmac_msg_len[] = {0, 16, 20, 64};

    cfg.keybits = AES_KEYBITS_128;
    memcpy(cfg.key, aes_cmac_128_key, sizeof(aes_cmac_128_key));
    for (uint8_t i = 0; i < sizeof(cmac_msg_len); i++) {
        drv_aes_cmac_start(OM_AES0, &cfg);
        drv_aes_cmac_crypt_continue(OM_AES0, aes_cmac_message, cmac_msg_len[i]);
        drv_aes_cmac_crypt_stop(OM_AES0, cmac_result);
        if (!example_aes_check(aes_cmac_128_expected_result[i], cmac_result, sizeof(cmac_result), "AES CMAC test")) {
            return;
        }
    }

    om_printf("AES CMAC test success\r\n");
}



/** @} */